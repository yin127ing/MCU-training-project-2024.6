# Keil uVision project Multi_Function_Display.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Multi_Function_Display +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER;..\OBJ
  group USER
    ./: main.c temperature.c delay.c
